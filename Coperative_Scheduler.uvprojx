# Keil uVision project Coperative_Scheduler.uvprojx, settings and files
target STM 32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TestScheduler
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group user
    ../../STM32F4-NUCLEO_PeriodScheduler_v1/: main.c
  group osKernel
    ../../STM32F4-NUCLEO_PeriodScheduler_v1/: osKernel.c osKernel.h osKernel.s
  group BSP
    ../../STM32F4-NUCLEO_PeriodScheduler_v1/: STM32F4_RTOS_BSP.c STM32F4_RTOS_BSP.h
software components: CMSIS:CORE 5.1.1, Device:STM32Cube Framework:Classic 1.7.4, Device:STM32Cube HAL:ADC 1.7.4, Device:STM32Cube HAL:Common 1.7.4, Device:STM32Cube HAL:Cortex 1.7.4, Device:STM32Cube HAL:DMA 1.7.4, Device:STM32Cube HAL:GPIO 1.7.4, Device:STM32Cube HAL:PWR 1.7.4, Device:STM32Cube HAL:RCC 1.7.4, Device:STM32Cube HAL:SPI 1.7.4, Device:STM32Cube HAL:TIM 1.7.4, Device:Startup 2.6.2
